# rootfs extras
IMAGE_INSTALL_append += " tcpdump "
IMAGE_INSTALL_append += " docker "
IMAGE_INSTALL_append += " python3-docker-compose "
